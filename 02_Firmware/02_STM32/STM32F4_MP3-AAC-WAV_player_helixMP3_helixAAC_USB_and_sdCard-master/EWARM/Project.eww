<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\audio_player_OD_NOWA.ewp</path>
  </project>
  <batchBuild />
</workspace>
